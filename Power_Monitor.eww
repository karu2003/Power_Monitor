<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\..\LCDandTimer\LCDandTimer.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\Power_Monitor.ewp</path>
    </project>
    <batchBuild />
</workspace>
