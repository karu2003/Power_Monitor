# IAR project Power_Monitor.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: TM4C123GH6PM TexasInstruments TM4C123GH6PM
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: ewarm; PART_TM4C123GH6PM; TARGET_IS_TM4C123_RB1
  ICCARM.CCIncludePath2: C:\ti\TivaWare_C_Series-2.2.0.295; ..
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: ewarm
  AARM.AUserIncludes: C:\ti\TivaWare_C_Series-2.2.0.295; $PROJ_DIR$
  OBJCOPY.OOCOutputFile: Power_Monitor.bin
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: Power_Monitor.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.IccLang: 1
  group lib
    C:/ti/TivaWare_C_Series-2.2.0.295/driverlib/ewarm/Exe/: driverlib.a
    C:/ti/TivaWare_C_Series-2.2.0.295/grlib/ewarm/Exe/: grlib.a
  group src
    ../drivers/: Kentec320x240x16_ssd2119_spi.c touch.c
    ./: Power_Monitor.c startup_ewarm.c
    C:/ti/TivaWare_C_Series-2.2.0.295/utils/: ustdlib.c
